Commit message: almost working with moveit

File: fh_description/robots/right_H1_ur5.urdf (robot description, URDF)
Before this commit: robot ur10, 1 links, 2 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.0 rpy=0.0 0.0 0.0 -> xyz=0.0 -1.0 1.0 rpy=0.0 0.0 0.0
